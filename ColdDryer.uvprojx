# Keil uVision project ColdDryer.uvprojx, settings and files
target LPC122x (ARM-ADS)
  device: LPC1225FBD64/301 NXP
  pack: Keil.LPC1200_DFP.1.0.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LPC122x
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source
    ./UserCode/: main.c
  group Documentation
    ./Doc/: Abstract.txt
  group ::Board Support
    C:/Keil_v5/ARM/PACK/Keil/MCB1200_BSP/1.0.0/Common/: ADC_MCB1200.c LED_MCB1200.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM0.lib
  group ::Device
    RTE/Device/LPC1225FBD64_301/: startup_LPC122x.s system_LPC122x.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Board Support:A/D Converter 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.0.0
